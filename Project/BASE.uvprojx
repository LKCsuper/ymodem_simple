# Keil uVision project BASE.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: YMODEM +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Library\STM32F4xx_StdPeriph_Driver\inc;..\Library\CMSIS;..\User;..\App\Led;..\App\peripheral_Init;..\App\peripheral_test;..\ThirtyParty\FreeRTOS\include;..\ThirtyParty\FreeRTOS\portable\RVDS\ARM_CM4F;..\App\flash;..\ThirtyParty\easyflash\inc;..\ThirtyParty\easyflash\plugins;..\ThirtyParty\easyflash\plugins\types\struct2json\inc;..\ThirtyParty\ymodem;..\Library\Bsp\inc;..\Library\Common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../User/: main.c stm32f4xx_it.c
  group Library
    ../Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group ymodem
    ../ThirtyParty/ymodem/: ymodem.c ymodem_common.c ymodem_config.c
  group Bsp
    ../Library/Bsp/: bsp_flash.c bsp_misc.c bsp_usart.c
  group CMSIS
    ../Library/CMSIS/: system_stm32f4xx.c startup_stm32f40_41xxx.s
